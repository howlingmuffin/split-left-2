## config/boards/Kconfig.defconfig
```kconfig
if SHIELD_Left_Boi

config ZMK_KEYBOARD_NAME
    default "Left_Boi"

config ZMK_SPLIT_ROLE_CENTRAL
    default y

endif
```
